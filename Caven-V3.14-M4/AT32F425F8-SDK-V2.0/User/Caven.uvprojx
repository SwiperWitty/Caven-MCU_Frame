# Keil uVision project Caven.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F425F8P7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Caven +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F425F8T7,USE_STDPERIPH_DRIVER,DEFAULT
  c include: ..\User;..\CMSIS;..\Config;..\SDK\inc;..\SDK\src;..\Startup;..\..\..\..\Caven-MCU_Lib\Mode;..\..\..\..\Caven-MCU_Lib\API;..\..\..\..\Caven-MCU_Lib\Base_AT32F425
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: Main.c User_Items.h
    ../../../../Caven-MCU_Lib/Base_AT32F425/: Items.h
  group Base
    ../../../../Caven-MCU_Lib/Base_AT32F425/: Base.c Base_ADC.c Base_Exist_GPIO.c Base_Flash.c Base_IIC.c Base_PWM.c Base_SPI.c Base_Sys_Time.c Base_UART.c
  group Mode
    ../../../../Caven-MCU_Lib/Mode/: BZZ.c Control_Mode.c DS18B20.c HC138.c HC595.c key.c lcd.c LED.c mlx90614.c Mode.c MODE_Motor.c MODE_MP3.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Steering_engine.c
  group API
    ../../../../Caven-MCU_Lib/API/: API.c Check_CRC16.c DATA_Handle.c Keyboard.c libcollections.c Time_Handle.c Caven.h
  group Config
    ../Config/: at32f425_clock.c at32f425_int.c system_at32f425.c
  group Startup
    ../Startup/: startup_at32f425.s
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h
  group SDK
    ../SDK/src/: at32f425_acc.c at32f425_adc.c at32f425_can.c at32f425_crc.c at32f425_crm.c at32f425_debug.c at32f425_dma.c at32f425_ertc.c at32f425_exint.c at32f425_flash.c at32f425_gpio.c at32f425_i2c.c at32f425_misc.c at32f425_pwc.c at32f425_scfg.c at32f425_spi.c at32f425_tmr.c at32f425_usart.c at32f425_usb.c at32f425_wdt.c at32f425_wwdt.c
