# Keil uVision project Caven.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ARET7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Caven +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403ARET7,DEFAULT
  c include: ..\User;..\CMSIS;..\SDK\inc;..\SDK\src;..\Startup;..\Config;..\..\..\..\Caven-MCU_Lib\API;..\..\..\..\Caven-MCU_Lib\Mode;..\..\..\..\Caven-MCU_Lib\Base_AT32F403A
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ./: Main.c
  group BASE
    ../../../../Caven-MCU_Lib/Base_AT32F403A/: ADC.c Base.c Base_Exist_GPIO.c Base_SPI.c DAC.c Encoder.c IIC.c PWM.c stmflash.c Sys_Time.c uart.c Items.h
  group MODE
    ../../../../Caven-MCU_Lib/Mode/: BZZ.c Control_Mode.c DS18B20.c HC138.c HC595.c key.c lcd.c LED.c mlx90614.c Mode.c MODE_Motor.c MODE_MP3.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Steering_engine.c
  group API
    ../../../../Caven-MCU_Lib/API/: API.c Check_CRC16.c DATA_Handle.c Keyboard.c libcollections.c Time_Handle.c Caven.h
  group SDK
    ../SDK/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group CMSIS
    ../CMSIS/: system_at32f403a_407.c arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h at32f403a_407.h at32f403a_407_conf_template.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iar.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h mpu_armv7.h mpu_armv8.h pmu_armv8.h system_at32f403a_407.h
  group Startup
    ../Startup/: startup_at32f403a_407.s
  group Config
    ../Config/: at32f403a_407_clock.c at32f403a_407_int.c
