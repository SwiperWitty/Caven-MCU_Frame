# Keil uVision project Cavendish.uvprojx, settings and files
target M3-Caven (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,ST,DEFAULT
  c include: ..\User;..\CMSIS;..\Startup;..\SDK\inc;..\SDK\src;..\Config;..\..\..\..\Caven-MCU_Lib\API;..\..\..\..\Caven-MCU_Lib\Mode;..\..\..\..\Caven-MCU_Lib\Base_STM32F103
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c User_Items.h
    ../../../../Caven-MCU_Lib/Base_STM32F103/: Items.h
  group Base
    ../../../../Caven-MCU_Lib/Base_STM32F103/: Base.c Base_ADC.c Base_Exist_GPIO.c Base_Flash.c Base_IIC.c Base_PWM.c Base_SPI.c Base_Sys_Time.c Base_UART.c
  group Mode
    ../../../../Caven-MCU_Lib/Mode/: BZZ.c Control_Mode.c DS18B20.c HC138.c HC595.c key.c lcd.c LED.c mlx90614.c Mode.c MODE_Motor.c MODE_MP3.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Steering_engine.c
  group API
    ../../../../Caven-MCU_Lib/API/: API.c Check_CRC16.c DATA_Handle.c Keyboard.c libcollections.c Time_Handle.c Caven.h
  group CMSIS
    ../CMSIS/: core_cm3.c
  group SDK
    ../SDK/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Config
    ../Config/: stm32f10x_it.c system_stm32f10x.c
